# Keil uVision project project.uvprojx, settings and files
target Target 1 (6240000::V6.24::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.3.1.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=5 wLevel=3
  c misc: -D__MICROLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  link misc: --diag_suppress=L6329
  group Source Group 1
    ./: main.c startup_stm32l476xx.s stm32l476xx.h LED.c SysClock.c UART.c UART_printf.c keypad.c OLED_I2C.c ssd1306.c ssd1306_fonts.c OLED_I2C.h ssd1306.h ssd1306_fonts.h ssd1306_conf.h README.md
software components: CMSIS:CORE 5.6.0
